## boards/shields/voltpad/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_VOLTPAD
    def_bool $(shields_list_contains,voltpad)
```
